# Keil uVision project BootLoader.uvprojx, settings and files
target GD32E230C_Bootloader (6220000::V6.22::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C_START
  AfterMake: fromelf --bin -o ".\bin_file\@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\Firmware\GD32E23x_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32E23x\Include;..\User;..\Hardware;..\Hardware\usart;..\Hardware\dma;..\App\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: gd32e23x_it.c main.c systick.c
  group Hardware
    ../Hardware/usart/: bsp_usart.c
    ../Hardware/dma/: bsp_dma.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
    ../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group App
    ../App/src/: xmodem.c
  group Firmware
    ../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.0.2
